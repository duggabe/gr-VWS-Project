options:
  parameters:
    author: Barry Duggan
    copyright: CC-BY-SA-4.0
    description: VWS SDR sim
    generate_options: no_gui
    id: VWS_SDR_sim_4
    output_language: python
    title: VWS_SDR_sim_4
  states: {}

blocks:
- name: fc_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '28'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_msgpair_to_var_0
  id: blocks_msgpair_to_var
  parameters:
    target: gain
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: |-
      Block DC from FunCube
      bypass if not needed
    length: '32'
    long_form: 'True'
    type: cc
  states: {state: bypassed}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nSimulate Pico functions to set frequency and gain\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"\n    reads input from a message port\n    sends set frequency message to FunCube\n    sets gain value\n    \"\"\"\n\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name='Simulate Pico functions',   # will show up in GRC\n            in_sig=None,\n            out_sig=None)\n        self.message_port_register_in(pmt.intern('msg_in'))\n        self.message_port_register_out(pmt.intern('set_gain'))\n        self.message_port_register_out(pmt.intern('set_freq'))\n        self.set_msg_handler(pmt.intern('msg_in'), self.handle_msg)\n        self._debug = 0     # set to 1 to turn on diagnostics\n        if (self._debug):\n            print (\"_debug =\", self._debug)\n\n    def handle_msg(self, msg):\n        try:\n            if (pmt.is_pair(msg)):\n                key0 = pmt.symbol_to_string(pmt.car(msg))\n                new_val = pmt.to_python(pmt.cdr(msg))\n            else:\n                print (\"Message is not a pair!\")\n                key0 = \"Bad\"\n                new_val = -1\n        except Exception as e:\n            gr.log.error(\"Error with message conversion: %s\" % str(e))\n        if (self._debug):\n            print (\"key:\", key0)\n            print (\"new_val =\", new_val)\n        if (key0 == \"freq\"):\n            self.message_port_pub(pmt.intern('set_freq'), msg)\n        elif (key0 == \"gain\"):\n            gain = (int)(new_val)\n            if (gain > 28):\n                gain = 28\n                print (\"Max gain is 28.\")\n            self.message_port_pub(pmt.intern('set_gain'),\n                pmt.cons(pmt.intern('gain'),\n                pmt.from_long(gain)))\n        else:\n            print (\"Message key is not valid!\")\n\n\n\n\n"
  states: {}
- name: funcube_fcdpp_0
  id: funcube_fcdpp
  parameters:
    comment: |-
      RF In
      RF Amp
      Mixer
      Differential Amp
    freq: 14.25e6
    if_gain: gain
    lnaswitch: '1'
    mixergainswitch: '1'
    ppm: '0'
    unit: '1 '
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Placeholder
      bypass if not needed
    cutoff_freq: '48000'
    decim: '1'
    gain: '1'
    samp_rate: fc_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {state: bypassed}
- name: note_0
  id: note
  parameters:
    comment: |-
      See instructions in the distro
      Operation section for
      setting the ZMQ Addresses
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: (int)(fc_rate/samp_rate)
    interp: '1'
    type: ccc
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:49204
    comment: |-
      See instructions in the distro
      Operation section for
      setting the ZMQ Address
    timeout: '100'
  states: {}

connections:
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [dc_blocker_xx_0, '0', rational_resampler_xxx_0, '0']
- [epy_block_0, set_freq, funcube_fcdpp_0, freq]
- [epy_block_0, set_gain, blocks_msgpair_to_var_0, inpair]
- [funcube_fcdpp_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_float_0, '0']
- [zeromq_sub_msg_source_0, out, blocks_message_debug_0, print]
- [zeromq_sub_msg_source_0, out, epy_block_0, msg_in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
