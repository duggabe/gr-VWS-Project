options:
  parameters:
    author: Barry Duggan
    description: VWS SDR simulation
    generate_options: no_gui
    id: VWS_SDR_sim_2
    output_language: python
    title: VWS_SDR_sim_2
  states: {}

blocks:
- name: fc_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: |-
      Bypass if not needed 
      to block DC from FunCube
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: funcube_fcdpp_0
  id: funcube_fcdpp
  parameters:
    comment: |-
      RF In
      RF Amp
      Mixer
      Differential Amp
    freq: 14.25e6
    if_gain: '6'
    lnaswitch: '1'
    mixergainswitch: '1'
    ppm: '0'
    unit: '1 '
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: Bypass if not needed
    cutoff_freq: '20000'
    decim: '1'
    gain: '1'
    samp_rate: fc_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: (int)(fc_rate/samp_rate)
    interp: '1'
    type: ccc
  states: {}
- name: zeromq_sub_msg_source_0
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:49204
    comment: |-
      Simulate Pico to set
      Freq and Gain
    timeout: '100'
  states: {}

connections:
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [dc_blocker_xx_0, '0', blocks_complex_to_float_0, '0']
- [funcube_fcdpp_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', dc_blocker_xx_0, '0']
- [zeromq_sub_msg_source_0, out, funcube_fcdpp_0, freq]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
