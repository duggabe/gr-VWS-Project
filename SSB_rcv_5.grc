options:
  parameters:
    author: Barry Duggan
    copyright: CC-BY-SA-4.0
    description: Weaver method
    generate_options: qt_gui
    id: SSB_rcv_5
    output_language: python
    title: SSB_rcv_5
  states: {}

blocks:
- name: band_pass_filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: '3500'
    low_cutoff_freq: '300'
    samp_rate: samp_rate
    type: complex_band_pass
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_msgdigitalnumbercontrol_0
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    comment: 7,0,1,3
    gui_hint: 7,0,1,3
    lbl: Frequency (Hz)
    maxFreqHz: 200e6
    minFreqHz: 300e3
    value: 14.250e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sb_sel
  id: variable_qtgui_chooser
  parameters:
    comment: 3,0,1,1
    gui_hint: 3,0,1,1
    label: Sideband
    label0: Upper
    label1: Lower
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: 2,0,1,3
    gui_hint: 2,0,1,3
    label: Volume
    start: '0'
    step: '0.05'
    stop: '1.0'
    value: '0.7'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume
    const: volume
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: sb_sel
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_swapiq_0
  id: blocks_swapiq
  parameters: {}
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: band_pass_filter_taps
    type: ccc
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      See instructions in the distro
      Operation section for
      setting the ZMQ Addresses
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    comment: 3,2,1,1
    gui_hint: 3,2,1,1
    key: '"gain"'
    label: '"RF Gain"'
    type: int
    value: '6'
  states: {}
- name: qtgui_edit_box_msg_0_0
  id: qtgui_edit_box_msg
  parameters:
    comment: 9,0,1,1
    gui_hint: 9,0,1,1
    key: freq
    label: Quick Set Frequency
    type: float
    value: 14.25e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 5,0,1,3
    fc: '0'
    fftsize: '1024'
    gui_hint: 5,0,1,3
    type: complex
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: 6,0,1,3
    fc: 14.25e6
    fftsize: '1024'
    gui_hint: 6,0,1,3
    showports: 'True'
    type: complex
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:49204
    timeout: '100'
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:49201
    comment: Audio rate = 48kHz
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_float_0, '1', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0, '0']
- [blocks_selector_0, '0', fft_filter_xxx_0, '0']
- [blocks_swapiq_0, '0', blocks_selector_0, '1']
- [fft_filter_xxx_0, '0', blocks_complex_to_float_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [qtgui_edit_box_msg_0, msg, zeromq_pub_msg_sink_0, in]
- [qtgui_edit_box_msg_0_0, msg, qtgui_msgdigitalnumbercontrol_0, valuein]
- [qtgui_msgdigitalnumbercontrol_0, valueout, qtgui_waterfall_sink_x_0, freq]
- [qtgui_msgdigitalnumbercontrol_0, valueout, zeromq_pub_msg_sink_0, in]
- [qtgui_waterfall_sink_x_0, freq, qtgui_msgdigitalnumbercontrol_0, valuein]
- [zeromq_sub_source_0, '0', blocks_selector_0, '0']
- [zeromq_sub_source_0, '0', blocks_swapiq_0, '0']
- [zeromq_sub_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
