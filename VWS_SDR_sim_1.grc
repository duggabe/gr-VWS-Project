options:
  parameters:
    author: Barry Duggan
    description: VWS SDR simulation
    generate_options: qt_gui
    id: VWS_SDR_sim_1
    output_language: python
    title: VWS_SDR_sim_1
  states: {}

blocks:
- name: fc_rate
  id: variable
  parameters:
    value: '192000'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: 1,0,1,3
    gui_hint: 1,0,1,3
    label: Rcv Gain
    rangeType: int
    start: '0'
    step: '1'
    stop: '20'
    value: '6'
    widget: slider
  states: {}
- name: out_sel
  id: variable_qtgui_chooser
  parameters:
    comment: 2,0,1,1
    gui_hint: 2,0,1,1
    label: Output selection
    label0: Audio
    label1: ZMQ
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: qtgui_msgdigitalnumbercontrol_0
  id: qtgui_msgdigitalnumbercontrol
  parameters:
    comment: 4,0,1,3
    gui_hint: 4,0,1,3
    lbl: Frequency (Hz)
    maxFreqHz: 200e6
    minFreqHz: 300e3
    value: 14.250e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: usrp_rate
  id: variable
  parameters:
    value: '768000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: out_sel
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    comment: |-
      Enable to block DC
      from FunCube
    length: '32'
    long_form: 'True'
    type: cc
  states: {state: bypassed}
- name: funcube_fcdpp_0
  id: funcube_fcdpp
  parameters:
    freq: 14.25e6
    if_gain: gain
    lnaswitch: '1'
    mixergainswitch: '1'
    ppm: '0'
    unit: '1 '
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: (int)(fc_rate/samp_rate)
    gain: '1'
    samp_rate: fc_rate
    type: fir_filter_ccf
    width: '2000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: usrp_rate
    comment: 3,0,1,3
    fc: 14.25e6
    fftsize: '1024'
    gui_hint: 3,0,1,3
    showports: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: (int)(usrp_rate/fc_rate)
    type: ccc
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:49201
    comment: |-
      USRP rate = 768kHz
      for testing
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_complex_to_float_0, '1', audio_sink_0, '1']
- [blocks_selector_0, '0', low_pass_filter_0, '0']
- [blocks_selector_0, '1', rational_resampler_xxx_0, '0']
- [dc_blocker_xx_0, '0', blocks_selector_0, '0']
- [dc_blocker_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [funcube_fcdpp_0, '0', dc_blocker_xx_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_float_0, '0']
- [qtgui_msgdigitalnumbercontrol_0, valueout, funcube_fcdpp_0, freq]
- [qtgui_msgdigitalnumbercontrol_0, valueout, qtgui_waterfall_sink_x_0, freq]
- [qtgui_waterfall_sink_x_0, freq, qtgui_msgdigitalnumbercontrol_0, valuein]
- [rational_resampler_xxx_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
